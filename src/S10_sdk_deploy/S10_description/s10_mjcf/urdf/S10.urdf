Commit message: fix urdf issue

File: src/S10_sdk_deploy/S10_description/s10_mjcf/urdf/S10.urdf (robot description, URDF)
Before this commit: robot S10, 20 links, 19 joints
Joints:
- joint hl_wheel_joint: origin xyz=0 0.054891 -0.18 rpy=0 0 0 -> xyz=0 0.045891 -0.18 rpy=0 0 0
